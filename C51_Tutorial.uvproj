# Keil uVision project C51_Tutorial.uvproj, settings and files
target src (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: C51_Tutorial +hex
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./src/main/: main.c
  group uart
    ./src/uart/: uart.c
  group i2c
    ./src/i2c/: i2c.c
  group spi
    ./src/spi/: spi.c
  group lcd1602
    ./src/lcd1602/: lcd1602.c
  group ds1302
    ./src/ds1302/: ds1302.c
  group eeprom
    ./src/eeprom/: eeprom.c
